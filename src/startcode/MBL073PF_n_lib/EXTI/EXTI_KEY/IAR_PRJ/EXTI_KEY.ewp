# IAR project EXTI_KEY.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32L073PF MM MM32L073PF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: MM32L073PF; USE_IAR
  ICCARM.CCIncludePath2: ..\..\..\..\..\Device\CMSIS\IAR_CORE; ..\..\..\..\..\Device\MM32L0xx\HAL_lib\inc; ..\..\..\..\..\Device\MM32L0xx\Include; ..\SYSTEM\delay; ..\SYSTEM\sys; ..\SYSTEM\uart; ..\HARDWARE\LED; ..\HARDWARE\EXTI; ..\HARDWARE\KEY
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IOToggle.srec
  ILINK.IlinkOutputFile: MBOUT.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HALlib
    ../../../../../Device/MM32L0xx/HAL_lib/src/: HAL_adc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
  group STARTUP
    ../../../../../Device/MM32L0xx/Source/IAR_StartAsm/: startup_MM32L0xx.s
    ../../../../../Device/MM32L0xx/Source/: system_MM32L0xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group USER
    ../USER/: main.c
