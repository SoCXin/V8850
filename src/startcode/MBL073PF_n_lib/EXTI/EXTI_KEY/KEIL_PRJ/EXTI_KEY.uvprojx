# Keil uVision project EXTI_KEY.uvprojx, settings and files
target MM32L0xx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.3
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\CMSIS\KEIL_CORE;..\..\..\..\..\Device\MM32L0xx\HAL_lib\inc;..\..\..\..\..\Device\MM32L0xx\Include;..\SYSTEM\delay;..\SYSTEM\uart;..\SYSTEM\sys;..\HARDWARE\LED;..\HARDWARE\EXTI;..\HARDWARE\KEY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../Device/MM32L0xx/Source/: system_MM32L0xx.c
    ../../../../../Device/MM32L0xx/Source/KEIL_StartAsm/: startup_MM32L0xx.s
  group HALlib
    ../../../../../Device/MM32L0xx/HAL_lib/src/: HAL_adc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_tim.c HAL_wwdg.c HAL_syscfg.c HAL_uart.c
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/UART/: uart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
  group README
    ../: README.TXT
