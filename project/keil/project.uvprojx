# Keil uVision project project.uvprojx, settings and files
target QITAS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\BSP;..\driver;..\..\src\Device\MM32L0xx\HAL_lib\inc;..\..\src\Device\MM32L0xx\Include;..\MDK;..\..\src\Device\CMSIS\KEIL_CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: main.c
  group BSP
    ../BSP/: led.c key.c
  group Driver
    ../driver/: delay.c uart.c can.c
  group STARTUP
    ../../src/Device/MM32L0xx/Source/: system_MM32L0xx.c
    ../../src/Device/MM32L0xx/Source/KEIL_StartAsm/: startup_MM32L0xx.s
  group HALlib
    ../../src/Device/MM32L0xx/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
