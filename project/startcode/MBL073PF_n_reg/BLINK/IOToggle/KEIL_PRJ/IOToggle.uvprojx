# Keil uVision project IOToggle.uvprojx, settings and files
target MM32L0xx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1
  c include: ..\..\..\..\..\Device\CMSIS\KEIL_CORE;..\..\..\..\..\Device\MM32L0xx\Include;..\SYSTEM\delay;..\SYSTEM\uart;..\SYSTEM\sys;..\HARDWARE\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../Device/MM32L0xx/Source/: system_MM32L0xx.c
    ../../../../../Device/MM32L0xx/Source/KEIL_StartAsm/: startup_MM32L0xx.s
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group README
    ../: README.TXT
